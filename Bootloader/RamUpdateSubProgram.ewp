# IAR project RamUpdateSubProgram.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F1612 MSP430F1612
  General.GStackSize2: 512
  General.GHeapSize2: 768
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  postbuild: FileMaker.exe
  XLINK.XclFile: lnk430F1612_RAM.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    System/: ProcessUpdate.c
    Debug/Exe/: RamUpdateSubProgram.h
  group ExternFlash
    System/Update/: AccessFlash.c BasicOLED.c ECC.c Flash.c

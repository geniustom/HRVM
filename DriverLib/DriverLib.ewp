# IAR project DriverLib.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 512
  General.GHeapSize2: 768
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: DriverExport.h DriverTest.c ISRMessage.c PortManger.c
  group ADC
    Adc/: ADCManger.c
  group BUZZER
    Buzzer/: Buzzer.c
  group ERROR
    ERROR/: ErrorCode.c
  group FLASH
    Flash/: EccStep.c Nand.c
  group GPIO
    Gpio/: GPIOdetect.c
  group GPIO/BUTTON
    Gpio/: Button.c
  group OLED
    Oled/: RTOS_OLED.C
  group POWER
    Power/: Power.c
  group TIMER
    Timer/: I2C_RTC_Chip.c RTC_Alarm.c TBManager.c WDT.C

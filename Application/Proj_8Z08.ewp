# IAR project Proj_8Z08.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsff.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 256
  General.GHeapSize2: 768
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430F1612.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: MSP430 Generic MSP430 device
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group DateTime
    DateTime/: Datetime.c
  group ECG
    Ecg/: EcgMeasure.c Fir.c Sdnn.c
  group LIB
    ../DriverLib/: DriverExport.h
    ../RTOS/Debug/Exe/: RTOS.r43
    ../RTOS/: RTOSExport.h
  group MENU
    Menu/: MenuUI.c RDMode.c
  group OTHER
    Other/: Storage.c Uart.c
